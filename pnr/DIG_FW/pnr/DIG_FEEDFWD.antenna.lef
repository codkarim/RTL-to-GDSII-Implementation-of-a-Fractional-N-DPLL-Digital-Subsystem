

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO DIG_FEEDFWD 
  PIN DLF_Ext_Data[14] 
    ANTENNAPARTIALMETALAREA 0.441 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.12121 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 33.75 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 169.046 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.59972 LAYER VIA56 ;
  END DLF_Ext_Data[14]
  PIN DLF_Ext_Data[13] 
    ANTENNAPARTIALMETALAREA 0.427 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.05387 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0598 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 40.9916 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 205.872 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.22575 LAYER VIA56 ;
  END DLF_Ext_Data[13]
  PIN DLF_Ext_Data[12] 
    ANTENNAPARTIALMETALAREA 0.413 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.98653 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0598 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 32.1455 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 163.322 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.62207 LAYER VIA56 ;
  END DLF_Ext_Data[12]
  PIN DLF_Ext_Data[11] 
    ANTENNAPARTIALMETALAREA 0.893 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.29533 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0598 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 38.6196 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 192.976 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.82943 LAYER VIA56 ;
  END DLF_Ext_Data[11]
  PIN DLF_Ext_Data[10] 
    ANTENNAPARTIALMETALAREA 0.343 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.64983 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 79.4128 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 391.966 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.06379 LAYER VIA56 ;
  END DLF_Ext_Data[10]
  PIN DLF_Ext_Data[9] 
    ANTENNAPARTIALMETALAREA 0.437 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.10197 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0598 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 81.209 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 386.446 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.62207 LAYER VIA56 ;
  END DLF_Ext_Data[9]
  PIN DLF_Ext_Data[8] 
    ANTENNAPARTIALMETALAREA 0.422 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.02982 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0598 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 31.7726 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 158.957 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.62207 LAYER VIA56 ;
  END DLF_Ext_Data[8]
  PIN DLF_Ext_Data[7] 
    ANTENNAPARTIALMETALAREA 0.199 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.95719 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.377 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.00577 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0598 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 68.2609 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 334.465 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.20736 LAYER VIA34 ;
  END DLF_Ext_Data[7]
  PIN DLF_Ext_Data[6] 
    ANTENNAPARTIALMETALAREA 0.99 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9543 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0598 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 19.5652 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 93.8043 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.603679 LAYER VIA23 ;
  END DLF_Ext_Data[6]
  PIN DLF_Ext_Data[5] 
    ANTENNAPARTIALMETALAREA 2.234 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.9379 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0598 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 40.3679 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 193.865 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.603679 LAYER VIA23 ;
  END DLF_Ext_Data[5]
  PIN DLF_Ext_Data[4] 
    ANTENNAPARTIALMETALAREA 2.49 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9769 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 3.781 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.379 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0598 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 79.5485 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 385.541 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.20736 LAYER VIA34 ;
  END DLF_Ext_Data[4]
  PIN DLF_Ext_Data[3] 
    ANTENNAPARTIALMETALAREA 1.575 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.76815 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.787 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.5979 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0598 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 57.4415 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 279.207 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.20736 LAYER VIA34 ;
  END DLF_Ext_Data[3]
  PIN DLF_Ext_Data[2] 
    ANTENNAPARTIALMETALAREA 2.425 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.8567 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 5.762 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.9076 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0598 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 115.652 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 559.2 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.81104 LAYER VIA34 ;
  END DLF_Ext_Data[2]
  PIN DLF_Ext_Data[1] 
    ANTENNAPARTIALMETALAREA 0.659 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.16979 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 5.47 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.5031 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0598 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 124.247 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 600.543 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.20736 LAYER VIA34 ;
  END DLF_Ext_Data[1]
  PIN DLF_Ext_Data[0] 
    ANTENNAPARTIALMETALAREA 0.509 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.44829 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 3.771 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.3309 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.534 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.57094 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0598 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 60.0167 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 294.811 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.41472 LAYER VIA45 ;
  END DLF_Ext_Data[0]
  PIN TDC_OUT[3] 
    ANTENNAPARTIALMETALAREA 0.275 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32275 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 5.537 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.0178 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 128.394 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 624.05 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END TDC_OUT[3]
  PIN TDC_OUT[2] 
    ANTENNAPARTIALMETALAREA 0.369 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.77489 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 3.361 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.3588 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 6.5 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.4574 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 115.103 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 560.122 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.05698 LAYER VIA45 ;
  END TDC_OUT[2]
  PIN TDC_OUT[1] 
    ANTENNAPARTIALMETALAREA 0.928 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.65608 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 5.762 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.9076 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 98.75 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 481.463 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.05698 LAYER VIA45 ;
  END TDC_OUT[1]
  PIN TDC_OUT[0] 
    ANTENNAPARTIALMETALAREA 1.393 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.70033 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 7.238 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.0072 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 130.417 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 633.78 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.57123 LAYER VIA45 ;
  END TDC_OUT[0]
  PIN KP[3] 
    ANTENNAPARTIALMETALAREA 2.346 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.2843 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 4.404 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.3756 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.1411 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 23.2374 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 111.999 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.12528 LAYER VIA45 ;
  END KP[3]
  PIN KP[2] 
    ANTENNAPARTIALMETALAREA 0.764 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.86724 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 5.747 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.0279 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.4931 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 42.1493 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 204.202 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.14313 LAYER VIA45 ;
  END KP[2]
  PIN KP[1] 
    ANTENNAPARTIALMETALAREA 2.134 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.6493 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.834 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 5.89702 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 28.1206 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.292308 LAYER VIA34 ;
  END KP[1]
  PIN KP[0] 
    ANTENNAPARTIALMETALAREA 3.926 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.0765 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.9825 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 9.53912 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 46.1253 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.439387 LAYER VIA34 ;
  END KP[0]
  PIN KI[3] 
    ANTENNAPARTIALMETALAREA 4.691 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.7561 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.247 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 20.832 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 101.414 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 0.730769 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.31 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.6859 LAYER METAL4 ;
    ANTENNAGATEAREA 2.6767 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 21.3214 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 103.912 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.54626 LAYER VIA45 ;
  END KI[3]
  PIN KI[2] 
    ANTENNAPARTIALMETALAREA 0.788 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.79028 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 2.627 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.8283 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.6692 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 13.9559 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 67.5939 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.13695 LAYER VIA45 ;
  END KI[2]
  PIN KI[1] 
    ANTENNAPARTIALMETALAREA 6.644 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 32.3424 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.0608 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 11.357 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 55.5424 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.507974 LAYER VIA34 ;
  END KI[1]
  PIN KI[0] 
    ANTENNAPARTIALMETALAREA 5.081 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.632 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8346 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 8.83086 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 43.1399 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.566719 LAYER VIA34 ;
  END KI[0]
  PIN DAC_IN[4] 
    ANTENNADIFFAREA 1.2 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 4.076 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.798 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 146.335 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 710.439 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.3546 LAYER VIA34 ;
  END DAC_IN[4]
  PIN DAC_IN[3] 
    ANTENNADIFFAREA 1.2 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 4.167 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.4281 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 86.7664 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 427.524 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END DAC_IN[3]
  PIN DAC_IN[2] 
    ANTENNADIFFAREA 1.2 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.077 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.1828 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 49.2617 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 243.517 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END DAC_IN[2]
  PIN DAC_IN[1] 
    ANTENNADIFFAREA 1.2 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 4.077 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.6104 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 125.247 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 605.395 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END DAC_IN[1]
  PIN DAC_IN[0] 
    ANTENNADIFFAREA 1.2 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 4.65 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.5589 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 100.181 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 488.439 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.3546 LAYER VIA34 ;
  END DAC_IN[0]
  PIN REF_CLK 
    ANTENNAPARTIALMETALAREA 0.869 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.17989 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 0.418767 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 2.03438 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END REF_CLK
  PIN RST 
    ANTENNAPARTIALMETALAREA 1.443 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.13323 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2002 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 11.0909 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 53.7221 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.540959 LAYER VIA34 ;
  END RST
  PIN DLF_Ext_En 
    ANTENNAPARTIALMETALAREA 0.532 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.55892 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.6419 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 34.2391 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 148.288 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.71002 LAYER VIA56 ;
  END DLF_Ext_En
  PIN SI 
    ANTENNAPARTIALMETALAREA 5.553 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 26.9023 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 106.804 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 516.685 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.677298 LAYER VIA23 ;
  END SI
  PIN SE 
    ANTENNAPARTIALMETALAREA 6.656 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 32.2078 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1066 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 205.891 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 992.285 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 2.70919 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 9.283 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 44.8436 LAYER METAL4 ;
    ANTENNAGATEAREA 0.1599 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 263.946 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 1272.73 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 3.61226 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 2.682 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0928 LAYER METAL5 ;
    ANTENNAGATEAREA 0.3822 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 270.964 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 1306.99 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.61226 LAYER VIA56 ;
  END SE
  PIN scan_clk 
    ANTENNAPARTIALMETALAREA 1.879 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.03799 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 0.773671 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 3.74147 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END scan_clk
  PIN scan_rst 
    ANTENNAPARTIALMETALAREA 1.346 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.47426 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2002 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 8.51399 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 41.4883 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.540959 LAYER VIA34 ;
  END scan_rst
  PIN test_mode 
    ANTENNAPARTIALMETALAREA 1.393 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.70033 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.5148 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 6.77495 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 31.4154 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.298028 LAYER VIA34 ;
  END test_mode
  PIN SO 
    ANTENNAPARTIALMETALAREA 1.955 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.40355 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.6 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 9.42 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 45.5026 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2756 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 55.8597 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 262.489 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.15948 LAYER VIA45 ;
  END SO
  PIN OV_FL 
    ANTENNADIFFAREA 1.431 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 0.989 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.75709 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2054 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 14.8965 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 75.0494 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.05453 LAYER VIA56 ;
  END OV_FL
  PIN UN_FL 
    ANTENNAPARTIALMETALAREA 1.322 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.35882 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.304 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.65464 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNADIFFAREA 1.737 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 12.061 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 58.3982 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2054 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 62.4348 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 303.552 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.05453 LAYER VIA56 ;
  END UN_FL
END DIG_FEEDFWD

END LIBRARY
