

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO DIG_FEEDBCK 
  PIN TDC_OUT[3] 
    ANTENNAPARTIALMETALAREA 0.497 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.39057 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4108 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 2.66602 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 11.9155 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.175755 LAYER VIA23 ;
  END TDC_OUT[3]
  PIN TDC_OUT[2] 
    ANTENNAPARTIALMETALAREA 0.919 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.42039 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 10.239 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 49.6344 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.4898 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 44.8449 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 215.913 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.850078 LAYER VIA34 ;
  END TDC_OUT[2]
  PIN TDC_OUT[1] 
    ANTENNAPARTIALMETALAREA 6.057 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 29.1342 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2054 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 32.5458 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 156.573 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 0.703018 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 12.098 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 58.5762 LAYER METAL4 ;
    ANTENNAGATEAREA 0.5239 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 55.638 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 268.381 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.13344 LAYER VIA45 ;
  END TDC_OUT[1]
  PIN TDC_OUT[0] 
    ANTENNAPARTIALMETALAREA 8.846 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 42.7417 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7436 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 32.9617 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 156.735 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.13344 LAYER VIA34 ;
  END TDC_OUT[0]
  PIN FCW[26] 
    ANTENNAPARTIALMETALAREA 1.281 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.16161 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 45.6731 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 226.163 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA56 ;
  END FCW[26]
  PIN FCW[25] 
    ANTENNAPARTIALMETALAREA 0.389 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.87109 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 62.24 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 305.85 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.59972 LAYER VIA56 ;
  END FCW[25]
  PIN FCW[24] 
    ANTENNAPARTIALMETALAREA 1.341 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.45021 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 44.0064 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 218.146 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA56 ;
  END FCW[24]
  PIN FCW[23] 
    ANTENNAPARTIALMETALAREA 0.387 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.86147 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 57.5392 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 283.239 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.59972 LAYER VIA56 ;
  END FCW[23]
  PIN FCW[22] 
    ANTENNAPARTIALMETALAREA 0.581 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.79461 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 52.9665 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 261.244 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA56 ;
  END FCW[22]
  PIN FCW[21] 
    ANTENNAPARTIALMETALAREA 1.29 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2049 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 71.5705 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 350.73 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.59972 LAYER VIA56 ;
  END FCW[21]
  PIN FCW[20] 
    ANTENNAPARTIALMETALAREA 0.582 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.79942 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 40.7158 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 202.319 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA56 ;
  END FCW[20]
  PIN FCW[19] 
    ANTENNAPARTIALMETALAREA 0.425 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.04425 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 34.5905 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 172.856 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA56 ;
  END FCW[19]
  PIN FCW[18] 
    ANTENNAPARTIALMETALAREA 1.111 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.34391 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 58.7073 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 288.857 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.59972 LAYER VIA56 ;
  END FCW[18]
  PIN FCW[17] 
    ANTENNAPARTIALMETALAREA 0.477 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.29437 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 23.7215 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 120.576 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA56 ;
  END FCW[17]
  PIN FCW[16] 
    ANTENNAPARTIALMETALAREA 1.007 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.84367 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 46.0007 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 227.739 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.59972 LAYER VIA56 ;
  END FCW[16]
  PIN FCW[15] 
    ANTENNAPARTIALMETALAREA 2.536 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1982 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 68.0378 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 333.737 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.59972 LAYER VIA56 ;
  END FCW[15]
  PIN FCW[14] 
    ANTENNAPARTIALMETALAREA 0.41 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9721 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 54.6902 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 269.535 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA56 ;
  END FCW[14]
  PIN FCW[13] 
    ANTENNAPARTIALMETALAREA 1.364 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.56084 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 50.958 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 251.583 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.59972 LAYER VIA56 ;
  END FCW[13]
  PIN FCW[12] 
    ANTENNAPARTIALMETALAREA 0.514 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.47234 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 23.0805 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 117.493 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA56 ;
  END FCW[12]
  PIN FCW[11] 
    ANTENNAPARTIALMETALAREA 0.501 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.40981 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 52.0264 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 256.722 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA56 ;
  END FCW[11]
  PIN FCW[10] 
    ANTENNAPARTIALMETALAREA 0.595 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.86195 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 83.7927 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 409.519 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA56 ;
  END FCW[10]
  PIN FCW[9] 
    ANTENNAPARTIALMETALAREA 1.057 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.08417 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 57.7386 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 284.198 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.59972 LAYER VIA56 ;
  END FCW[9]
  PIN FCW[8] 
    ANTENNAPARTIALMETALAREA 1.355 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.51755 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 57.5107 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 283.102 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.59972 LAYER VIA56 ;
  END FCW[8]
  PIN FCW[7] 
    ANTENNAPARTIALMETALAREA 1.735 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.34535 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.236 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.9476 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 51.3284 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 250.624 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA34 ;
  END FCW[7]
  PIN FCW[6] 
    ANTENNAPARTIALMETALAREA 1.377 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.62337 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.026 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.93746 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 34.3198 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 168.813 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END FCW[6]
  PIN FCW[5] 
    ANTENNAPARTIALMETALAREA 1.757 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.45117 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 4.523 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.948 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 113.949 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 551.831 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA34 ;
  END FCW[5]
  PIN FCW[4] 
    ANTENNAPARTIALMETALAREA 1.645 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.91245 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 4.919 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.8528 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 85.844 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 416.644 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END FCW[4]
  PIN FCW[3] 
    ANTENNAPARTIALMETALAREA 3.067 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.9447 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 45.6588 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 220.613 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.514245 LAYER VIA23 ;
  END FCW[3]
  PIN FCW[2] 
    ANTENNAPARTIALMETALAREA 2.583 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4242 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 6.477 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.3468 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 96.4281 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 467.554 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA34 ;
  END FCW[2]
  PIN FCW[1] 
    ANTENNAPARTIALMETALAREA 1.391 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.69071 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 7.311 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 35.3583 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 133.807 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 647.346 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA34 ;
  END FCW[1]
  PIN FCW[0] 
    ANTENNAPARTIALMETALAREA 1.525 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.33525 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 6.5 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.4574 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 103.565 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 501.882 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA34 ;
  END FCW[0]
  PIN MMD_CNTRL[7] 
    ANTENNADIFFAREA 1.41 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.263 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.07503 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 311.344 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1500.52 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END MMD_CNTRL[7]
  PIN MMD_CNTRL[6] 
    ANTENNAPARTIALMETALAREA 1.797 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.64357 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNADIFFAREA 1.41 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 15.31 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 73.8335 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 350.237 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 1698.43 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA45 ;
  END MMD_CNTRL[6]
  PIN MMD_CNTRL[5] 
    ANTENNAPARTIALMETALAREA 3.092 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.8725 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 1.41 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 15.602 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 75.238 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 364.609 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 1767.56 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA45 ;
  END MMD_CNTRL[5]
  PIN MMD_CNTRL[4] 
    ANTENNAPARTIALMETALAREA 1.576 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.58056 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 1.41 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 17.807 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 85.8441 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 432.132 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 2092.34 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA45 ;
  END MMD_CNTRL[4]
  PIN MMD_CNTRL[3] 
    ANTENNAPARTIALMETALAREA 4.383 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.0822 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 1.41 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 18.613 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 89.7209 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 442.995 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 2140.99 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA45 ;
  END MMD_CNTRL[3]
  PIN MMD_CNTRL[2] 
    ANTENNAPARTIALMETALAREA 5.751 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.6623 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 1.41 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 21.096 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 101.664 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 468.887 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 2265.52 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA45 ;
  END MMD_CNTRL[2]
  PIN MMD_CNTRL[1] 
    ANTENNAPARTIALMETALAREA 6.305 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.5195 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 1.41 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 24.048 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 115.863 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 478.361 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 2314.71 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA45 ;
  END MMD_CNTRL[1]
  PIN MMD_CNTRL[0] 
    ANTENNAPARTIALMETALAREA 8.527 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 41.0149 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNADIFFAREA 1.431 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 25.993 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 125.219 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 542.995 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 2621.99 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA45 ;
  END MMD_CNTRL[0]
  PIN DCW[8] 
    ANTENNADIFFAREA 1.431 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 3.38 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.4502 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNADIFFAREA 1.431 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 0.222 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.26022 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 1.431 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 29.87 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 143.867 LAYER METAL5 ;
  END DCW[8]
  PIN SO 
    ANTENNAPARTIALMETALAREA 5.762 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.7152 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 13.096 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 63.1842 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 1.431 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 29.87 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 143.867 LAYER METAL5 ;
  END SO
  PIN DCW[7] 
    ANTENNADIFFAREA 1.41 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 13.505 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 64.9591 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 266.316 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1283.94 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END DCW[7]
  PIN DCW[6] 
    ANTENNADIFFAREA 1.41 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 3.451 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.7917 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 99.1857 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 482.541 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END DCW[6]
  PIN DCW[5] 
    ANTENNADIFFAREA 1.41 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.708 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2179 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 106.353 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 517.015 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END DCW[5]
  PIN DCW[4] 
    ANTENNADIFFAREA 1.41 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 3.103 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.9254 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0689 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 93.4224 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 454.709 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.0479 LAYER VIA34 ;
  END DCW[4]
  PIN DCW[3] 
    ANTENNADIFFAREA 1.41 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 4.799 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.0832 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 152.507 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 735.405 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END DCW[3]
  PIN DCW[2] 
    ANTENNADIFFAREA 1.41 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.725 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.29725 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0689 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 89.9536 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 438.025 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.57184 LAYER VIA34 ;
  END DCW[2]
  PIN DCW[1] 
    ANTENNADIFFAREA 1.41 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 3.868 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.7975 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 81.0244 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 395.185 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END DCW[1]
  PIN DCW[0] 
    ANTENNADIFFAREA 1.41 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 4.279 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.7744 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 91.212 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 444.188 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END DCW[0]
  PIN FB_CLK 
    ANTENNAPARTIALMETALAREA 2.761 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2804 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 8.304 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.1346 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1534 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 77.4291 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 375.914 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.17666 LAYER VIA45 ;
  END FB_CLK
  PIN RST 
    ANTENNAPARTIALMETALAREA 1.575 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.57575 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 11.83 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 57.0947 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2002 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 72.4576 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 350.249 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.721279 LAYER VIA45 ;
  END RST
  PIN SI 
    ANTENNAPARTIALMETALAREA 0.828 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.98268 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 18.1548 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 86.6732 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.677298 LAYER VIA23 ;
  END SI
  PIN SE 
    ANTENNAPARTIALMETALAREA 9.598 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 46.1664 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1066 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 111.069 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 534.388 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 2.70919 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 8.608 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 41.7893 LAYER METAL4 ;
    ANTENNAGATEAREA 0.2756 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 142.303 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 686.018 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 4.5029 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 11.903 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 57.4458 LAYER METAL5 ;
    ANTENNAGATEAREA 0.3822 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 173.446 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 836.321 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.5029 LAYER VIA56 ;
  END SE
  PIN scan_clk 
    ANTENNAPARTIALMETALAREA 1.932 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.29292 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1547 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 16.8507 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 81.8975 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.700065 LAYER VIA34 ;
  END scan_clk
  PIN scan_rst 
    ANTENNAPARTIALMETALAREA 0.955 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.59355 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2002 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 6.22128 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 30.4604 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.540959 LAYER VIA34 ;
  END scan_rst
  PIN test_mode 
    ANTENNAPARTIALMETALAREA 0.881 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.23761 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 6.532 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.6113 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.5148 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 18.5047 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 89.5175 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.631119 LAYER VIA45 ;
  END test_mode
  PIN test_si2 
    ANTENNAPARTIALMETALAREA 0.687 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.30447 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 6.395 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.9524 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 143.333 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 699.61 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA45 ;
  END test_si2
  PIN LMS_OV_FL 
    ANTENNADIFFAREA 1.431 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 18.615 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 89.5382 LAYER METAL3 ;
  END LMS_OV_FL
  PIN LMS_UN_FL 
    ANTENNADIFFAREA 1.431 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 23.322 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 112.179 LAYER METAL3 ;
  END LMS_UN_FL
  PIN test_so2 
    ANTENNADIFFAREA 0.6 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 6.776 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.5926 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 130.667 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 625.698 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA23 ;
    ANTENNADIFFAREA 0.6 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.826 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.97546 LAYER METAL3 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 164.926 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 794.093 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA34 ;
    ANTENNADIFFAREA 0.6 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 4.755 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.064 LAYER METAL4 ;
    ANTENNAGATEAREA 0.8749 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 170.361 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 820.454 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA45 ;
  END test_so2
END DIG_FEEDBCK

END LIBRARY
